<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\CMSIS\Include\arm_common_tables.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CMSIS\Include\arm_const_structs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CMSIS\Include\arm_math.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CMSIS\Include\core_cm0.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CMSIS\Include\core_cm0plus.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CMSIS\Include\core_cm3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CMSIS\Include\core_cm4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CMSIS\Include\core_cm7.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CMSIS\Include\core_cmFunc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CMSIS\Include\core_cmInstr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CMSIS\Include\core_cmSimd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CMSIS\Include\core_sc000.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CMSIS\Include\core_sc300.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\CMSIS\stm32f4xx.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\stm32f4xx_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\system_stm32f4xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\system_stm32f4xx.h</name>
    </file>
  </group>
  <group>
    <name>CONFIG</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\CONFIG\inc\gpio_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CONFIG\inc\IRQHandler_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CONFIG\inc\nvic_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CONFIG\inc\sysclock_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CONFIG\inc\tim_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CONFIG\inc\usart_config.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\CONFIG\src\gpio_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CONFIG\src\IRQHandler_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CONFIG\src\nvic_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CONFIG\src\sysclock_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CONFIG\src\tim_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CONFIG\src\usart_config.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>DRIVER</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\DRIVER\inc\delay.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\inc\dmpKey.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\inc\dmpmap.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\inc\inv_mpu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\inc\inv_mpu_dmp_motion_driver.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\inc\mpu6050.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\inc\myiic.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\inc\sys.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\inc\upload.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\DRIVER\src\delay.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\src\inv_mpu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\src\inv_mpu_dmp_motion_driver.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\src\mpu6050.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\src\myiic.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\src\sys.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\src\upload.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>FWLIB</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\misc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_can.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_cec.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_crc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_cryp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_dac.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_dbgmcu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_dcmi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_dfsdm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_dma2d.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_dsi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_flash_ramfunc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_fmc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_fmpi2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_fsmc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_hash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_iwdg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_lptim.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_ltdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_pwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_qspi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_rcc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_rng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_rtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_sai.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_sdio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_spdifrx.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_syscfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_tim.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_usart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\inc\stm32f4xx_wwdg.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_cec.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_cryp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_cryp_aes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_cryp_des.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_cryp_tdes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_dcmi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_dfsdm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_dma2d.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_dsi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_flash_ramfunc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_fmpi2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_hash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_hash_md5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_hash_sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_lptim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_ltdc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_qspi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_rng.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_sai.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_spdifrx.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_syscfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLIB\src\stm32f4xx_wwdg.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>STARTUP</name>
    <file>
      <name>$PROJ_DIR$\STARTUP\startup_stm32f40_41xxx.s</name>
    </file>
  </group>
  <group>
    <name>USER</name>
    <file>
      <name>$PROJ_DIR$\USER\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\stm32f4xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\stm32f4xx_it.h</name>
    </file>
  </group>
</project>


