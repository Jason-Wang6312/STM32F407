# IAR project STM32F4xx Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ; CMSIS\; CMSIS\Include\; HARDWARE\delay\; HARDWARE\gpio\; HARDWARE\IRQHandler\; HARDWARE\nvic\; HARDWARE\sysclock\; HARDWARE\tim\; HARDWARE\usart\; HARDWARE\sys\; HARDWARE\spi\; HARDWARE\nrf24l01\; FWLIB\inc\; USER\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F4xx Template.hex
  ILINK.IlinkOutputFile: STM32F4xx Template.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    CMSIS/: stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group CMSIS/include
    CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group FWLIB/inc
    FWLIB/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group FWLIB/src
    FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group HARDWARE/delay
    HARDWARE/delay/: delay.c delay.h
  group HARDWARE/gpio
    HARDWARE/gpio/: gpio_config.c gpio_config.h
  group HARDWARE/IRQHandler
    HARDWARE/IRQHandler/: IRQHandler_config.c IRQHandler_config.h
  group HARDWARE/nrf24l01
    HARDWARE/nrf24l01/: 24l01.c 24l01.h
  group HARDWARE/nvic
    HARDWARE/nvic/: nvic_config.c nvic_config.h
  group HARDWARE/spi
    HARDWARE/spi/: spi.c spi.h
  group HARDWARE/sys
    HARDWARE/sys/: sys.c sys.h
  group HARDWARE/sysclock
    HARDWARE/sysclock/: sysclock_config.c sysclock_config.h
  group HARDWARE/tim
    HARDWARE/tim/: tim_config.c tim_config.h
  group HARDWARE/usart
    HARDWARE/usart/: usart_config.c usart_config.h
  group STARTUP
    STARTUP/: startup_stm32f40_41xxx.s
  group USER
    USER/: main.c stm32f4xx_it.c stm32f4xx_it.h
